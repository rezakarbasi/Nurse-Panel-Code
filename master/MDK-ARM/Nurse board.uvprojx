# Keil uVision project Nurse board.uvprojx, settings and files
target Nurse board (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Nurse board
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dac.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_pwr.c
  group LCD
    ../Src/LCD/: ILI9341_GFX.c ILI9341_STM32_Driver.c
  group File & FatFs
    ../Src/FatFS/: SD_functions.c
    ../Src/FatFS/Src/: unicode.c syscall.c ffunicode.c ffsystem.c ff.c fat_sd_spi.c diskio.c
  group Communication
    ../Src/: Master.c
  group Audio
    ../Src/: Audio.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: dac.c gpio.c dma.c tim.c stm32f1xx_hal_msp.c spi.c adc.c main.c stm32f1xx_it.c usart.c
software components: CMSIS:CORE 4.1.0
