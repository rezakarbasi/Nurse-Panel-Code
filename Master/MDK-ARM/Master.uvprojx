# Keil uVision project Master.uvprojx, settings and files
target Master (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Master
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc;  ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group LCD
    ../Src/LCD/: ILI9341_GFX.c ILI9341_STM32_Driver.c LCD.c
  group Files & FatFS
    ../Src/FatFS/Src/: diskio.c fat_sd_spi.c ff.c ffsystem.c ffunicode.c syscall.c unicode.c
    ../Src/FatFS/: SD_functions.c
  group Keypad
    ../Src/: Keypad.c
  group Audio
    ../Src/: Audio.c
  group Application/User
    ../Src/: gpio.c stm32f1xx_it.c dma.c tim.c adc.c usart.c dac.c spi.c main.c stm32f1xx_hal_msp.c Master.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_dac.c stm32f1xx_hal_flash.c stm32f1xx_hal.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c
software components: CMSIS:CORE 4.3.0
